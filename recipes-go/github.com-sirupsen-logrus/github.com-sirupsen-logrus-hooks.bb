require github.com-sirupsen-logrus.inc

do_compile(){

}